<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CRTC_CAR.ewp</path>
  </project>
  <batchBuild />
</workspace>
